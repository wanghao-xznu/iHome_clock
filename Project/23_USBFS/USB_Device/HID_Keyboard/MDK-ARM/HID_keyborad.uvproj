# Keil uVision project HID_keyborad.uvproj, settings and files
target USB_DHID (ARM-ADS)
  device: GD32F307VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: HID_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F30X_CL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Library\Firmware\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Library\Firmware\GD32F30x_usbfs_driver\Include;..\..\..\..\..\Library\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c usb_delay.c hid_core.c gd32f30x_it.c
  group CMSIS
    ../../../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_StdPeriph_Driver
    ../../../../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group GD32F30x_EVAL
    ../../../../../Library/Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group USB_Driver
    ../../../../../Library/Firmware/GD32F30x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
