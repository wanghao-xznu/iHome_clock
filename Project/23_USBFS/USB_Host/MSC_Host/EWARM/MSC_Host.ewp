# IAR project MSC_Host.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F30X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Library\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\..\Library\Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\..\..\Library\Firmware\GD32F30x_usbfs_driver\Include; ..\..\..\..\..\Library\Utilities; ..\..\..\..\..\Library\Utilities\LCD_Commom; ..\..\..\..\..\Library\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F307xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f30x_it.c main.c usb_delay.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c usbh_usr.c
  group CMSIS
    ../../../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Library/Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group GD32F30x_EVAL
    ../../../../../Library/Utilities/: gd32f307c_eval.c gd32f307c_lcd_eval.c
    ../../../../../Library/Utilities/LCD_Commom/: lcd_log.c
  group GD32F30x_Peripherals
    ../../../../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
  group USB_Driver
    ../../../../../Library/Firmware/GD32F30x_usbfs_driver/Source/: usb_core.c usbh_core.c usbh_ctrl.c usbh_hcs.c usbh_int.c usbh_std.c
