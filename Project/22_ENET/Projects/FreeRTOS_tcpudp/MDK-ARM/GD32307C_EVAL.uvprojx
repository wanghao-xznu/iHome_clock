# Keil uVision project GD32307C_EVAL.uvprojx, settings and files
target GD32F307C_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20017FFF)IROM(0x08000000-0x0803FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: GD32307C_EVAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL
  c include: ..\..\..\..\..\Library\Firmware\GD32F30x_standard_peripheral\Include;..\..\..\..\..\Library\Utilities;..\inc;..\..\..\Third_party\lwip-1.4.1\src\include;..\..\..\Third_party\lwip-1.4.1\src\include\ipv4;..\..\..\Third_party\lwip-1.4.1\src\include\netif;..\..\..\Third_party\lwip-1.4.1\src\include\lwip;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x\FreeRTOS;..\..\..\Third_party\lwip-1.4.1\port\GD32F30x\arch;..\..\..\Third_party\FreeRTOS-8.2.3\include;..\..\..\Third_party\FreeRTOS-8.2.3\portable\RVDS\ARM_CM3;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: main.c netconf.c tcp_client.c udp_echo.c gd32f30x_enet_eval.c gd32f30x_it.c ntp_client.c clock_application.c display_dp.c gpio_i2c_driver.c app_flash.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../../../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group GD32F30x_EVAL
    ../../../../../Library/Utilities/: gd32f307c_eval.c
  group Startup
    ../../../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Lwip
    ../../../Third_party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../Third_party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../Third_party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../Third_party/lwip-1.4.1/src/netif/: etharp.c
  group Lwip_port
    ../../../Third_party/lwip-1.4.1/port/GD32F30x/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../../../Third_party/FreeRTOS-8.2.3/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/MemMang/: heap_2.c
    ../../../Third_party/FreeRTOS-8.2.3/portable/RVDS/ARM_CM3/: port.c
  group Doc
    ../: readme.txt
